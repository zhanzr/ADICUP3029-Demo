# Keil uVision project adicup3029_t1.uvprojx, settings and files
target sha (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ADuCM3029 Analog Devices
  pack: AnalogDevices.ADuCM302x_DFP.2.0.0
  cpu: IRAM(0x20000000,0x04000) IRAM2(0x20040000,0x04000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: adicup3029_t1
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ADI_DEBUG __ADUCM3029__
  c include: ..\mdk_prj
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  memory RVCT10: RAM 0x20040000 size 0x4000
  group Source
    ./: main.c
software components: CMSIS:CORE 5.0.2, Device:Drivers:ADC 2.0.0, Device:Drivers:CRC 2.0.0, Device:Drivers:Crypto 2.0.0, Device:Drivers:DMA 2.0.0, Device:Drivers:GPIO 2.0.0, Device:Drivers:Interrupt 2.0.0, Device:Drivers:Power 2.0.0, Device:Drivers:RNG 2.0.0, Device:Drivers:RTC 2.0.0, Device:Drivers:SPI 2.0.0, Device:Drivers:UART 2.0.0, Device:Drivers:WDT 2.0.0, Device:Examples Support 2.0.0, Device:Global Configuration 2.0.0, Device:Retarget_UART 2.0.0, Device:Startup 2.0.0, Compiler:I/O:STDERR 1.2.1, Compiler:I/O:STDIN 1.2.1, Compiler:I/O:STDOUT 1.2.1, Compiler:I/O:TTY 1.2.1
